VERSION 5.8 ;
UNITS DATABASE MICRONS 1000 ;
MACRO AND2_X1 
CLASS CORE ;
SIZE 2 BY 2 ;
PIN A DIRECTION INPUT ; END A
PIN B DIRECTION INPUT ; END B
PIN Y DIRECTION OUTPUT ; END Y
END AND2_X1
MACRO OR2_X1 
CLASS CORE ;
SIZE 2 BY 2 ;
PIN A DIRECTION INPUT ; END A
PIN B DIRECTION INPUT ; END B
PIN Y DIRECTION OUTPUT ; END Y
END OR2_X1
MACRO XOR2_X1 
CLASS CORE ;
SIZE 2 BY 2 ;
PIN A DIRECTION INPUT ; END A
PIN B DIRECTION INPUT ; END B
PIN Y DIRECTION OUTPUT ; END Y
END XOR2_X1
MACRO INV_X1 
CLASS CORE ;
SIZE 2 BY 2 ;
PIN A DIRECTION INPUT ; END A
PIN B DIRECTION INPUT ; END B
PIN Y DIRECTION OUTPUT ; END Y
END INV_X1
MACRO FA_X1 
CLASS CORE ;
SIZE 2 BY 2 ;
PIN A DIRECTION INPUT ; END A
PIN B DIRECTION INPUT ; END B
PIN Y DIRECTION OUTPUT ; END Y
END FA_X1
MACRO MACRO_BLOCK
CLASS BLOCK ;
SIZE 50 BY 50 ;
PIN A DIRECTION INPUT ; END A
PIN B DIRECTION INPUT ; END B
PIN Y DIRECTION OUTPUT ; END Y
END MACRO_BLOCK
